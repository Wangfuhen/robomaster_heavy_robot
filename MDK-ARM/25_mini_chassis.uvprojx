# Keil uVision project 25_mini_chassis.uvprojx, settings and files
target 25_mini_chassis (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 25_mini_chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../balance_bsp/scm_bsp/can_init;../balance_bsp/scm_bsp/double_buffer_dma_init;../balance_bsp/scm_bsp/imu_driver/bm1088;../balance_bsp/scm_bsp/imu_driver/ist8310;../balance_application/all_task;../balance_bsp/crg_filter;../balance_application/can;../balance_application/control_alg/pid;../balance_application/control_alg/lqr;../balance_application/remote;../balance_application/vofa;../balance_bsp/math_bsp;D:/package/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/DSP/Include;../Middlewares/ST/ARM/DSP/Inc;../balance_application/RM_referee;../balance_application/RM_usb;../balance_bsp/usart_bsp;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../algorithm;..\mini_ui;..\mini_ui;..\MDK-ARM
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group balance_bsp
    ../balance_bsp/math_bsp/: c_data_typedef.h
    ../balance_bsp/scm_bsp/can_init/: can_init.c can_init.h
    ../balance_bsp/scm_bsp/double_buffer_dma_init/: double_dma_init.c double_dma_init.h
    ../balance_bsp/scm_bsp/imu_driver/bm1088/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h
    ../balance_bsp/scm_bsp/imu_driver/ist8310/: ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h
  group user_task
    ../balance_application/all_task/: debug_task.c debug_task.h ins_task.c ins_task.h chassis_task.c chassis_task.h referee_usart_task.c referee_usart_task.h ui_task.c ui_task.h
  group balance_application
    ../balance_application/can/: can_user.c can_user.h
    ../balance_application/control_alg/lqr/: joint_motor_lqr.c joint_motor_lqr.h
    ../balance_application/control_alg/pid/: pid.c pid.h
    ../balance_application/remote/: dt7_remote_read.c dt7_remote_read.h
    ../balance_application/vofa/: vofa.c vofa.h
    ../balance_application/RM_referee/: protocol.h referee.c referee.h
  group crg_bsp
    ../balance_bsp/crg_filter/: crg_filter.c crg_filter.h crg_kalman_filter.h crg_kalman_filter.c crg_matrix_cacl.c crg_matrix_cacl.h
  group rm_bsp
    ../balance_bsp/usart_bsp/: bsp_usart.c
    ../balance_application/RM_usb/: CRC8_CRC16.c fifo.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group ahrs
    ../algorithm/: user_lib.c MahonyAHRS.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group ui_task
    ../mini_ui/: ui_first_Ungroup_1.c ui_first_Ungroup_1.h ui_interface.c ui_interface.h ui_types.h ui_first_Ungroup_2.c ui_first_Ungroup_2.h ui_first_Ungroup_0.c ui_first_Ungroup_0.h ui.h ui_first_Ungroup_3.h ui_first_Ungroup_3.c
software components: CMSIS:CORE 5.4.0
